# Keil uVision project bus.uvprojx, settings and files
target bus MM32F103CBT6 (6190000::V6.19::ARMCLANG)
  device: MM32F103CBT MindMotion
  pack: MindMotion.MM32F103x8xB_DFP.1.4.8
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(48000000) ELITTLE
  output: bus +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5
  c misc: -ffp-contract=off -Wall -Wextra
  c include: ..\Core\Inc;..\Drivers\Inc;..\Application\Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\bus.sct
  link misc: --entry=Reset_Handler
  group Core
    ../Core/Inc/: board.h
    ../Core/Src/: board.c main.c startup_mm32f103.c
  group Drivers
    ../Drivers/Inc/: flash.h links.h usb_hid.h
    ../Drivers/Src/: flash.c links.c usb_hid.c
  group Application
    ../Application/Inc/: actions.h controller.h
    ../Application/Src/: actions.c controller.c
